<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild/>
  <project>
    <path>$WS_DIR$\SAM7X_EK.ewp</path>
  </project>
</workspace>
