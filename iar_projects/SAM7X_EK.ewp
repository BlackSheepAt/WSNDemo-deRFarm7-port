# IAR project SAM7X_EK.ewp, settings and files
configuration All_Sam7xEk_At91sam7x256_Rf230B (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: BOARD_SAM7X_EK; AT91SAM7X256; HAL_48MHz; STACK_TYPE_ALL; AT86RF230B; NO_SECURITY_MODE
  ICCARM.CCDiagSuppress: Pa050,Pe188
  ICCARM.PreInclude: MakerulesBc_All_At91sam7x256_Rf230B_Iar.h
  ICCARM.CCIncludePath2: ..; ../include; ../../../BitCloud/Components/BSP/ATML_SAM7X_EK/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/USBClasses/common/include; ../../../BitCloud/Components/HAL/drivers/USBClasses/VCP/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/include/private; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/arm7tdmi/at91sam7x256/common/include; ../../../BitCloud/Components/HAL/arm7tdmi/at91sam7x256/atmlEvalKit/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF230/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF230/MAC_HWD/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: AT91SAM7X256
  OBJCOPY.OOCOutputFile: WSNDemo.srec
  ILINK.IlinkOutputFile: WSNDemo.out
  ILINK.IlinkIcfFile: ../linkerScr/at91SAM7X256_FLASH.icf
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Sam7xEkRf2xx_At91sam7x256_48MHz_Iar.a; ../../../BitCloud/lib/libBc_All_At91sam7x256_Rf230B_Iar.a; ../../../BitCloud/lib/FirmwareBoot_Iar.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration All_Sec_Sam7xEk_At91sam7x256_Rf230B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAM7X_EK; AT91SAM7X256; HAL_48MHz; STACK_TYPE_ALL; AT86RF230B; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_At91sam7x256_Rf230B_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Sam7xEkRf2xx_At91sam7x256_48MHz_Iar.a; ../../../BitCloud/lib/libBc_All_Sec_At91sam7x256_Rf230B_Iar.a; ../../../BitCloud/lib/FirmwareBoot_Iar.o
configuration All_Sam7xEk_At91sam7x256_Rf231 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAM7X_EK; AT91SAM7X256; HAL_48MHz; STACK_TYPE_ALL; AT86RF231; NO_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_At91sam7x256_Rf231_Iar.h
  ICCARM.CCIncludePath2: ..; ../include; ../../../BitCloud/Components/BSP/ATML_SAM7X_EK/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/USBClasses/common/include; ../../../BitCloud/Components/HAL/drivers/USBClasses/VCP/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/include/private; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/arm7tdmi/at91sam7x256/common/include; ../../../BitCloud/Components/HAL/arm7tdmi/at91sam7x256/atmlEvalKit/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/MAC_HWD/include
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Sam7xEkRf2xx_At91sam7x256_48MHz_Iar.a; ../../../BitCloud/lib/libBc_All_At91sam7x256_Rf231_Iar.a; ../../../BitCloud/lib/FirmwareBoot_Iar.o
configuration All_Sec_Sam7xEk_At91sam7x256_Rf231 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAM7X_EK; AT91SAM7X256; HAL_48MHz; STACK_TYPE_ALL; AT86RF231; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_At91sam7x256_Rf231_Iar.h
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Sam7xEkRf2xx_At91sam7x256_48MHz_Iar.a; ../../../BitCloud/lib/libBc_All_Sec_At91sam7x256_Rf231_Iar.a; ../../../BitCloud/lib/FirmwareBoot_Iar.o
configuration All_Sam7xEk_At91sam7x256_Rf212 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAM7X_EK; AT91SAM7X256; HAL_48MHz; STACK_TYPE_ALL; AT86RF212; NO_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_At91sam7x256_Rf212_Iar.h
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Sam7xEkRf2xx_At91sam7x256_48MHz_Iar.a; ../../../BitCloud/lib/libBc_All_At91sam7x256_Rf212_Iar.a; ../../../BitCloud/lib/FirmwareBoot_Iar.o
configuration All_Sec_Sam7xEk_At91sam7x256_Rf212 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAM7X_EK; AT91SAM7X256; HAL_48MHz; STACK_TYPE_ALL; AT86RF212; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_At91sam7x256_Rf212_Iar.h
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Sam7xEkRf2xx_At91sam7x256_48MHz_Iar.a; ../../../BitCloud/lib/libBc_All_Sec_At91sam7x256_Rf212_Iar.a; ../../../BitCloud/lib/FirmwareBoot_Iar.o
  group src
    ../src/: WSNSensorManager.c WSNVisualizer.c WSNEndDevice.c WSNCoord.c WSNMessageSender.c WSNCommandHandler.c WSNRouter.c WSNDemoApp.c WSNUARTManager.c
  group include
    ../include/: WSNZclManager.h WSNVisualizer.h WSNUARTManager.h WSNMessageSender.h WSNCoord.h WSNDemoApp.h WSNEndDevice.h WSNRouter.h WSNCommandHandler.h WSNSensorManager.h WSNCommand.h serialInterface.h
  group configuration
    ../: configuration.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: pdsMem.c pdsWriteData.c pdsDataServer.c pdsInit.c pdsTimer.c pdsEvents.c pdsMemAccess.c pdsCrcService.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h
  group Components/PersistDataServer/include/private
    ../../../BitCloud/Components/PersistDataServer/include/private/: pdsDbg.h pdsMemAccess.h pdsCrcService.h pdsTimer.h pdsMem.h pdsWriteData.h pdsMemAbstract.h
  group Components/USBClasses/VCP/src
    ../../../BitCloud/Components/HAL/drivers/USBClasses/VCP/src/: vcpVirtualUsart.c vcpCdcProtocol.c
  group Components/USBClasses/common/src
    ../../../BitCloud/Components/HAL/drivers/USBClasses/common/src/: usbSetupProcess.c usbDescriptors.c usbEnumeration.c
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/ATML_SAM7X_EK/src/: i2ceeprom.c fakeBSP.c leds.c bspTaskManager.c joystick.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaulfts.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csParamTable.h csDbg.h csBuffers.h csSIB.h
